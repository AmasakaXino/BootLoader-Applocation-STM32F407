# Keil uVision project Project.uvprojx, settings and files
target application (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __CC_ARM,__TARGET_FPU_VFP
  c include: ..\..\BSP\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Task\inc;..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\FreeRTOS\Source\include;..\..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Libraries\lwip-2.1.2\src\include;..\..\Libraries\lwip-2.1.2\port\STM32F4x7;..\..\Libraries\STM32F4x7_ETH_Driver\inc
  memory RVCT4: ROM 0x80004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\application.sct
  group User
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h lwipopts.h
  group BSP
    ../../BSP/src/: Ali_iot.c bsp_hash.c bsp_lan8720.c bsp_random.c bsp_uart.c netconf.c
  group Task
    ../../Task/src/: task_init.c
  group Libraries/CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Libraries/FreeRTOS/Source
    ../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Libraries/MemMang
    ../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Libraries/RVDS
    ../../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Libraries/api
    ../../Libraries/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Libraries/core/ipv4
    ../../Libraries/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Libraries/core
    ../../Libraries/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Libraries/netif
    ../../Libraries/lwip-2.1.2/src/netif/: ethernet.c
  group Libraries/port
    ../../Libraries/lwip-2.1.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group BootLoader
    ../../Bootloader/: main.c tim.c uart.c
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\bootloader.sct
